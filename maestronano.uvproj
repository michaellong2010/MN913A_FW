# Keil uVision project maestronano.uvproj, settings and files
target MN-913A (ARM-ADS)
  device: NUC120RE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: maestronano
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c include: .\;..\..\..\..\HW;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\..\..\Include;..\..\..\Include\Driver;..\..\..\..\CMSIS\CM0\;..\..\..\Include\USB;.\header
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ./: startup_NUC1xx.s
    ../../../../CMSIS/CM0/: system_NUC1xx.c core_cm0.c
  group Library files
    ../../../Src/Driver/: DrvSYS.c DrvUART.c DrvGPIO.c DrvTimer.c DrvSPI.c DrvI2C.c
    ./source/: DrvPWM.c retarget.c
    ./USB_HID/: DrvUSB.c
  group Source files
    ./source/: main.c init.c measurement.c peripheral.c
    ./USB_HID/: HIDTransfer_API.c HIDTransferSys.c
